# Repository mauro-starspec/Elevation_Pivot_Daughter-Board (continued)

## KiCad design controller/Elevation_Controller.kicad_pcb (continued)

Schematic: 10_stepper_interfaces.kicad_sch, Elevation Control_Gigabit

Parts:
C1037, C1042, C1069, C1072: 1uF; C_1206_3216Metric; MANUFACTURER_PART_NUMBER CL31B105KCHNNNE; LCSC C13832
C1038, C1040, C1053, C1070, C1071, C1097: 0.1uF; C_0805_2012Metric; MANUFACTURER_PART_NUMBER CL21B104KCFNNNE; LCSC C28233
C1051, C1096: 10nF; C_0805_2012Metric; MANUFACTURER_PART_NUMBER CL21B103KCANNNC; LCSC C18741
C1052, C1098: 4.7uF; C_1210_3225Metric; MANUFACTURER_PART_NUMBER CL32B475KCVZNWE; LCSC C17288249
D1001, D1004: TPD1E10B06DPYR; MANUFACTURER_PART_NUMBER TPD1E10B06DPYR; LCSC C48260
J1003, J1006: DE9_Socket_MountingHoles; DSUB-9_Socket_Horizontal_P2.77x2.84mm_EdgePinOffset7.70mm_H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; MANUFACTURER_PART_NUMBER 5747844-4; LCSC C305941
Q1001, Q1002, Q1003, Q1004, Q1005, Q1013: 2N7002KQ-7; SOT-23; MANUFACTURER_PART_NUMBER 2N7002KQ-7; LCSC C111971
R1027, R1055: 4.7K; R_0805_2012Metric; MANUFACTURER_PART_NUMBER RC0805FR-074K7L; LCSC C60816
R1028, R1029, R1036, R1037, R1045, R1046, R1047, R1048, R1057, R1058: 10K; R_0805_2012Metric; MANUFACTURER_PART_NUMBER RC0805FR-0710KL; LCSC C84376
R1030, R1031, R1032, R1049, R1050, R1051: 100; R_0805_2012Metric; MANUFACTURER_PART_NUMBER RC0805FR-07100RL; LCSC C105577
R1033, R1034, R1035, R1052, R1053, R1054: 47K; R_0805_2012Metric; MANUFACTURER_PART_NUMBER RC0805FR-0747KL; LCSC C126351
R1038, R1056: 10; R_2512_6332Metric_Pad1.40x3.35mm_HandSolder; MANUFACTURER_PART_NUMBER 352210RFT; LCSC C2075790
U1010, U1018: ISO6762DWR; ISO6762QDWRQ1; MANUFACTURER_PART_NUMBER ISO6762DWR; LCSC C5216395
U1011, U1012, U1019, U1020: TPD2E2U06QDBZRQ1; SOT95P237X95-3N; MANUFACTURER_PART_NUMBER TPD2E2U06QDBZRQ1; LCSC C488151

Connections:
3V3_DIG: C1037.1, C1038.2, C1069.1, C1070.2, R1029.1, R1036.1, R1037.1, R1046.1, R1047.1, R1048.1, R1057.1, R1058.1, U1010.1 (VCC1), U1018.1 (VCC1); also elsewhere on the board
+5V_FIELD: C1040.2, C1042.1, C1071.2, C1072.1, R1033.1, R1034.1, R1035.1, R1038.1, R1052.1, R1053.1, R1054.1, R1056.1, U1010.16 (VCC2), U1018.16 (VCC2); also elsewhere on the board
-BATT: C1040.1, C1042.2, C1051.2, C1052.1, C1053.1, C1071.1, C1072.2, C1096.2, C1097.1, C1098.1, D1001.2, D1004.2, J1003.0 (PAD), J1006.0 (PAD), Q1001.2 (S), Q1002.2 (S), Q1003.2 (S), Q1004.2 (S), Q1005.2 (S), Q1013.2 (S), R1027.2, R1055.2, U1010.9 (GND2), U1010.10 (INF), U1011.3 (GND), U1012.3 (GND), U1018.9 (GND2), U1018.10 (INF), U1019.3 (GND), U1020.3 (GND); also elsewhere on the board
GND: C1037.2, C1038.1, C1069.2, C1070.1, R1028.1, R1045.1, U1010.8 (GND1), U1018.8 (GND1); also elsewhere on the board
unnamed: J1006.2, Q1001.3 (D), U1011.2 (IO2)
unnamed: Q1001.1 (G), R1031.1, R1034.2
unnamed: J1006.3, Q1002.3 (D), U1012.1 (IO1)
unnamed: Q1002.1 (G), R1032.1, R1035.2
unnamed: J1003.1, Q1003.3 (D), U1019.1 (IO1)
unnamed: Q1003.1 (G), R1049.1, R1052.2
unnamed: J1003.2, Q1004.3 (D), U1019.2 (IO2)
unnamed: Q1004.1 (G), R1050.1, R1054.2
unnamed: J1003.3, Q1005.3 (D), U1020.1 (IO1)
unnamed: Q1005.1 (G), R1051.1, R1053.2
unnamed: J1006.1, Q1013.3 (D), U1011.1 (IO1)
unnamed: Q1013.1 (G), R1030.1, R1033.2
unnamed: R1030.2, U1010.15 (OUTA)
unnamed: R1031.2, U1010.14 (OUTB)
unnamed: R1032.2, U1010.13 (OUTC)
unnamed: R1049.2, U1018.15 (OUTA)
unnamed: R1050.2, U1018.14 (OUTB)
unnamed: R1051.2, U1018.13 (OUTC)
PORT_ENC_POS_PRESET: U1010.12 (OUTD); also elsewhere on the board
PORT_ENC_PRESET_N: R1057.2, U1010.5 (IND); also elsewhere on the board
PORT_STR8_5V_FIELD: C1052.2, C1053.2, D1001.1, J1006.6, J1006.7, J1006.8, J1006.9, R1038.2
PORT_STR8_DIR_CMD: R1029.2, U1010.3 (INB); also elsewhere on the board
PORT_STR8_DISABLE: R1036.2, U1010.4 (INC); also elsewhere on the board
PORT_STR8_FAULT: R1037.2, U1010.6 (OUTE); also elsewhere on the board
PORT_STR8_FAULT_RAW: C1051.1, J1006.4, R1027.1, U1010.11 (INE), U1012.2 (IO2)
PORT_STR8_STEP_CMD: R1028.2, U1010.2 (INA); also elsewhere on the board
STAR_ENC_POS_PRESET: U1018.12 (OUTD); also elsewhere on the board
STAR_ENC_PRESET_N: R1058.2, U1018.5 (IND); also elsewhere on the board
STAR_STR8_5V_FIELD: C1097.2, C1098.2, D1004.1, J1003.6, J1003.7, J1003.8, J1003.9, R1056.2
STAR_STR8_DIR_CMD: R1046.2, U1018.3 (INB); also elsewhere on the board
STAR_STR8_DISABLE: R1047.2, U1018.4 (INC); also elsewhere on the board
STAR_STR8_FAULT: R1048.2, U1018.6 (OUTE); also elsewhere on the board
STAR_STR8_FAULT_RAW: C1096.1, J1003.4, R1055.1, U1018.11 (INE), U1020.2 (IO2)
STAR_STR8_STEP_CMD: R1045.2, U1018.2 (INA); also elsewhere on the board

Notes on the sheet:
Signal ESD protection
STR8 CONTROL - STM32 SIGNALS ACTIVE HIGH PE9/TIM1_CH1 STEP: idle LOW; generate HIGH pulses, minimum 3 us. PE11 DIR: set direction before starting STEP pulses. PE13 STR8_DISABLE: HIGH = motor disabled; keep HIGH during reset/startup. PE14 STR8_FAULT: HIGH = fault; stop STEP and assert STR8_DISABLE. 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
Digital isolator

Schematic: 11_ssi_interfaces.kicad_sch, Elevation Control_Gigabit

Parts:
C1002, C1009, C1056, C1057, C1062, C1065, C1099: 0.1uF; C_0805_2012Metric; MANUFACTURER_PART_NUMBER CL21B104KCFNNNE; LCSC C28233
C1003, C1017: 10uF; C_2220_5750Metric; MANUFACTURER_PART_NUMBER FS55X106K101EHG; LCSC C153035
C1006, C1058, C1063, C1064: 1uF; C_1206_3216Metric; MANUFACTURER_PART_NUMBER CL31B105KCHNNNE; LCSC C13832
D1002, D1003: TPD1E10B06DPYR; PARTREV G; LCSC C48260
J1002, J1004: DE9_Socket_MountingHoles; DSUB-9_Socket_Horizontal_P2.77x2.84mm_EdgePinOffset7.70mm_H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; MANUFACTURER_PART_NUMBER 5747844-4; LCSC C305941
Q1006, Q1007: 2N7002KQ-7; SOT-23; MANUFACTURER_PART_NUMBER 2N7002KQ-7; LCSC C111971
R1002, R1004: 120; R_0805_2012Metric; MANUFACTURER_PART_NUMBER RC0805FR-07120RL; LCSC C114245
R1039, R1040: 10K; R_0805_2012Metric; MANUFACTURER_PART_NUMBER RC0805FR-0710KL; LCSC C84376
R1059, R1060: 2.2K; R_0805_2012Metric; MANUFACTURER_PART_NUMBER RC0805FR-072K2L; LCSC C114561
R1061, R1062: 47K; R_0805_2012Metric; MANUFACTURER_PART_NUMBER RC0805FR-0747KL; LCSC C126351
U1003, U1006, U1008, U1009: TPD2E2U06QDBZRQ1; SOT95P237X95-3N; MANUFACTURER_PART_NUMBER TPD2E2U06QDBZRQ1; LCSC C488151
U1007, U1016: ISO1432DWR; MANUFACTURER_PART_NUMBER ISO1432DWR; LCSC C2672372
U1022: SN74LVC2G07DCKR(UMW); SN74LVC2G07; MANUFACTURER_PART_NUMBER SN74LVC2G07DCKR(UMW); LCSC C7394023
U1026, U1027: TPD1E10B09DPYR; MANUFACTURER_PART_NUMBER TPD1E10B09DPYR; LCSC C88031

Connections:
3V3_DIG: C1006.1, C1056.2, C1064.1, C1065.2, R1039.2, R1040.2, U1007.1 (VCC1), U1007.5 (DE), U1016.1 (VCC1), U1016.5 (DE); also elsewhere on the board
+5V_ENC_PORT: C1057.2, C1058.1, R1059.1, R1061.1, U1007.16 (VCC2); also elsewhere on the board
+5V_ENC_STAR: C1062.2, C1063.1, R1060.1, R1062.1, U1016.16 (VCC2); also elsewhere on the board
+5V_FIELD: C1099.2, U1022.5 (VCC); also elsewhere on the board
+6.5V_ENC_PORT: C1002.2, C1017.1, J1004.1, U1026.1 (K); also elsewhere on the board
+6.5V_ENC_STAR: C1003.1, C1009.2, J1002.1, U1027.1 (K); also elsewhere on the board
-BATT: C1002.1, C1003.2, C1009.1, C1017.2, C1057.1, C1058.2, C1062.1, C1063.2, C1099.1, D1002.2, D1003.2, J1002.0 (PAD), J1002.2, J1002.9, J1004.0 (PAD), J1004.2, J1004.9, Q1006.2 (S), Q1007.2 (S), U1003.3 (GND), U1006.3 (GND), U1007.9 (GND2), U1007.15 (GND2__1), U1008.3 (GND), U1009.3 (GND), U1016.9 (GND2), U1016.15 (GND2__1), U1022.2 (GND), U1026.2 (A), U1027.2 (A); also elsewhere on the board
GND: C1006.2, C1056.1, C1064.2, C1065.1, U1007.2 (GND1), U1007.4 (~RE), U1007.8 (GND1__1), U1016.2 (GND1), U1016.4 (~RE), U1016.8 (GND1__1); also elsewhere on the board
unnamed: D1003.1, J1004.5, Q1006.3 (D), R1059.2
unnamed: Q1006.1 (G), R1061.2, U1022.6 (1Y)
unnamed: D1002.1, J1002.5, Q1007.3 (D), R1060.2
unnamed: Q1007.1 (G), R1062.2, U1022.4 (2Y)
PORT_ENC_CLK_N: J1004.7, U1006.1 (IO1), U1007.12 (Z)
PORT_ENC_CLK_P: J1004.3, U1006.2 (IO2), U1007.11 (Y)
PORT_ENC_DATA_N: J1004.6, R1002.1, U1003.1 (IO1), U1007.13 (B)
PORT_ENC_DATA_P: J1004.4, R1002.2, U1003.2 (IO2), U1007.14 (A)
PORT_ENC_POS_PRESET: U1022.1 (1A); also elsewhere on the board
PORT_SSI_CLK: R1039.1, U1007.6 (D); also elsewhere on the board
PORT_SSI_DATA: U1007.3 (R); also elsewhere on the board
STAR_ENC_CLK_N: J1002.7, U1009.1 (IO1), U1016.12 (Z)
STAR_ENC_CLK_P: J1002.3, U1009.2 (IO2), U1016.11 (Y)
STAR_ENC_DATA_N: J1002.6, R1004.1, U1008.1 (IO1), U1016.13 (B)
STAR_ENC_DATA_P: J1002.4, R1004.2, U1008.2 (IO2), U1016.14 (A)
STAR_ENC_POS_PRESET: U1022.3 (2A); also elsewhere on the board
STAR_SSI_CLK: R1040.1, U1016.6 (D); also elsewhere on the board
STAR_SSI_DATA: U1016.3 (R); also elsewhere on the board

Notes on the sheet:
STM32 encoder data output
Isolated RS-422/485 transceiver
Signal ESD protection
Supply transient protection
STM32 encoder data input
STM32 encoder clock output
Dual open-drain buffer

Board: 4 copper layers, 258 parts (79 on the bottom side), 164 nets, no tracks yet.
